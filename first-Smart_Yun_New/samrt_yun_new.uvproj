# Keil uVision project samrt_yun_new.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: samrt_yun_new +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Control;.\Delay;.\Key;.\Usart
  group Source Group 1
    ./: main.c
    ./Usart/: Smart_Usart.c Usart_communication.c Usart_Code.c
    ./Control/: Control_Mcu.c
    ./Key/: Key_Config.c
    ./Delay/: delay.c
